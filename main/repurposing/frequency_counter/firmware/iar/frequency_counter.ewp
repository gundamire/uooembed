# IAR project frequency_counter.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: tiny861 ATtiny861
  ICCAVR.CCDefines: __IAR__; ENABLE_BIT_DEFINITIONS
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgtiny861.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: pegasus_hub_control.c
